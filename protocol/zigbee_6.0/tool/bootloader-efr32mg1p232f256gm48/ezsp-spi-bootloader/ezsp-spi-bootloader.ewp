# IAR project ezsp-spi-bootloader.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFR32MG1P133F256GM48 SiliconLaboratories EFR32MG1P133F256GM48
  ICCARM.CCDefines: BOARD_HEADER="../../platform/base/../../hardware/kit/EFR32MG1_BRD4151A/config/hal-config-board.h"; PLATFORM_HEADER="../../platform/base/hal/micro/cortexm3/compiler/iar-boot.h"; EMBER_STACK_CAN_MULTIMAC; HAL_MICRO; CORTEXM3; CORTEXM3_EFR32; PHY_NULL; BOARD_BRD4151A; CORTEXM3_EFM32_MICRO; EMLIB_USER_CONFIG; __RELEASE__; EFR32MG1P232F256GM48; EFR32MG1P; EFR32_SERIES1_CONFIG1_MICRO; CORTEXM3_EFR32_MICRO; IEEE802154PHY_FIXED_PROTIMER_TICK; MAX_RADIO_POWER=0; BTL_HAS_EZSP_SPI; DISABLE_IDLING_DELAY; BOOTLOADER; BOOTLOADER_TYPE=BL_EXT_TYPE_EZSP_SPI; HAL_CONFIG="hal-config.h"; APP_HAL_CONFIG="hal/micro/cortexm3/efm32/hal-config/ezsp-spi-bootloader.h"; FRAMEWORK_HAL_CONFIG="app/hal-config/zigbee-hal-config.h"; EM_MSC_RUN_FROM_FLASH; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\..\..\platform\base\HAL\; ..\..\..\..\..\platform\base\; ../../../../../platform/base/hal/micro/cortexm3/efm32/config; ../../../../../platform/emdrv/common/inc; ../../../../../platform/emdrv/rtcdrv/inc; ../../../../../platform/emdrv/sleep/inc; ../../../../../platform/emdrv/aesdrv/inc; ../../../../../platform/emdrv/aesdrv/src; ../../../../../platform/emdrv/trace/inc; ../../../../../platform/emdrv/gpiointerrupt/inc; ../../../../../platform/emdrv/ecode; ../../../../../platform/emdrv/uartdrv/inc; ../../../../../platform/emdrv/spidrv/inc; ../../../../../platform/emdrv/dmadrv/inc; ../../../../../platform/emdrv/ustimer/inc; ../../../../../platform/emdrv/cryptodrv/src; ../../../../../platform/emdrv/tempdrv/inc; ../../../../../platform/base/hal/micro/cortexm3/common; ../../../../../platform/emlib/inc; ../../../../../platform/emdrv/rtcdrv/inc; ../../../../../platform/CMSIS/Include; ../../../../../hardware/kit/common/bsp; ../../../../../hardware/kit/common/drivers; ../../../../../hardware/kit/common/halconfig; ../../../../../platform/base/hal/micro/cortexm3/efm32; ../../../../../platform/base/hal/micro/cortexm3/efm32/efr32; ../../../../../platform/middleware/glib; ../../../../../platform/middleware/glib/glib; ../../../../../platform/middleware/glib/dmd; ../../../../../platform/base/../halconfig/inc/hal-config/; ../../../../../platform/base/hal/micro/cortexm3/efm32/hal-config; ../../../../../platform/bootloader; ../../../../../platform/Device/SiliconLabs/EFR32MG1P/Include; ../../../../../hardware/kit/EFR32MG1_BRD4151A/config; ../../../../../platform/base/hal/plugin; ../../../app/util; ../../../../../platform/radio/rail_lib/chip/efr32/rf/rfprotocol/ieee802154/cortex; ../../../../../platform/radio/rail_lib/chip/efr32/rf/rfprotocol/ieee802154/config; ../../../../../platform/radio/rail_lib/chip/efr32/rf/rfprotocol/ieee802154; ../../../../../platform/radio/rail_lib/chip/efr32/rf/common/cortex; ../../../../../platform/radio/rail_lib/chip/efr32/rf/common; ../../../../../platform/radio/rail_lib/chip/efr32; ../../../../../platform/radio/rail_lib/chip/utils; ../../../../../platform/radio/rail_lib/common; ../../../../../platform/emdrv/cryptodrv/src; ../../../../../platform/radio/rail_lib/chip/efr32/rf/rfprotocol/ieee802154/config/efr32xg1; ../../../../../util/third_party/mbedtls/include; ../../../../../util/third_party/mbedtls/sl_crypto/include; ../../../../../util/third_party/mbedtls/sl_crypto/src; ../../../../../platform/base/lwip/; ../../../../../platform/base/lwip/src/include/; ../../../../../platform/base/lwip/contrib/port/FreeRTOS/EM358X/; ../../../../../platform/base/lwip/src/include/ipv4/; ../../../../../platform/base/lwip/src/include/ipv6/; ../../../app/test/micrium_cfg/; ../../../../../util/third_party/micrium/MicriumOS/; ../../../../../util/third_party/micrium/MicriumOS/rtos/common/include/; ../../../../../util/third_party/micrium/MicriumOS/rtos/kernel/include/
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: BOARD_HEADER="../../platform/base/../../hardware/kit/EFR32MG1_BRD4151A/config/hal-config-board.h"; PLATFORM_HEADER="../../platform/base/hal/micro/cortexm3/compiler/iar-boot.h"; EMBER_STACK_CAN_MULTIMAC; HAL_MICRO; CORTEXM3; CORTEXM3_EFR32; PHY_NULL; BOARD_BRD4151A; CORTEXM3_EFM32_MICRO; EMLIB_USER_CONFIG; __RELEASE__; EFR32MG1P232F256GM48; EFR32MG1P; EFR32_SERIES1_CONFIG1_MICRO; CORTEXM3_EFR32_MICRO; IEEE802154PHY_FIXED_PROTIMER_TICK; MAX_RADIO_POWER=0; BTL_HAS_EZSP_SPI; DISABLE_IDLING_DELAY; BOOTLOADER; BOOTLOADER_TYPE=BL_EXT_TYPE_EZSP_SPI; HAL_CONFIG="hal-config.h"; APP_HAL_CONFIG="hal/micro/cortexm3/efm32/hal-config/ezsp-spi-bootloader.h"; FRAMEWORK_HAL_CONFIG="app/hal-config/zigbee-hal-config.h"; EM_MSC_RUN_FROM_FLASH
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ezsp-spi-bootloader.bin
  postbuild: "ielftool.exe" "$TARGET_BPATH$.out" "$TARGET_BPATH$.s37" --srec --srec-s3only
  ILINK.IlinkOutputFile: ezsp-spi-bootloader.out
  ILINK.IlinkConfigDefines: BOOTLOADER=1; FLASH_SIZE=256K; RAM_SIZE=32K
  ILINK.IlinkIcfFile: ../../../../../platform/base/hal/micro/cortexm3/efm32/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../../../platform/base/hal/plugin/antenna-stub/: antenna-stub.c
    ../../../../../platform/base/hal/micro/cortexm3/efm32/bootloader/: bootloader-gpio-ezsp-spi.c btl-ezsp-spi-device.c cstartup-iar-boot-entry.s79 cstartup-iar-boot.c
    ../../../../../platform/base/hal/micro/cortexm3/common/: btl-ezsp-spi-protocol.c btl-ezsp-spi.c
    ../../../../../platform/base/hal/micro/generic/: crc.c mem-util.c random.c
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_ldma.c em_msc.c em_rmu.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../../build/ezsp-spi-bootloader-library-cortexm3-iarboot-efr32mg1p-null/: ezsp-spi-bootloader-library.a
    ../../../../../platform/base/hal/micro/cortexm3/efm32/: isr-stubs.s79 led.c mfg-token.c micro-common.c
    ../../../../../platform/Device/SiliconLabs/EFR32MG1P/Source/: system_efr32mg1p.c
    ../../../../../platform/emdrv/ustimer/src/: ustimer.c
